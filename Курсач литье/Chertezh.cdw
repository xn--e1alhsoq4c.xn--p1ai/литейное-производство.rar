# KOMPAS-3D drawing (Chertezh.cdw)

Views: Вид 1
Texts:
  Царь
  POLYTEH
  Ra3,2
  Ra1,6
  Rz20
Dimensions and other numbers on the sheet: 1; 0,8; 20; 35; 1:1